# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\Stm32lib\CMSIS\Core\CM3;.\Stm32lib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./startup/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group stddriver
    ./stddriver/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_exti.c
  group user
    ./user/: main.c GPIO.c sys.c EXTI.c systick.c
